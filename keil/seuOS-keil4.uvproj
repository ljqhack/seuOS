# Keil uVision project seuOS-keil4.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: seuOS-keil4
  c flags: Optim=1
  c include: ..\..\seuOS;..\os;..\arm\CM3
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group arm
    ../arm/CM3/: system_stm32f10x.c core_cm3.c
    ../arm/CM3/startup/arm/: startup_stm32f10x_hd.s
  group seuos
    ../os/: seuos.c
  group app
    ../: app.c
